# Keil uVision project SWM190_StdPeriph_Driver.uvprojx, settings and files
target SWM190 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM190xB Synwit
  pack: Synwit.SWM32_DFP.1.20.10
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM190_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM190_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
    ./APP/: jumpApp.c
  group CSL\StdPD
    ./CSL/SWM190_StdPeriph_Driver/: SWM190_port.c SWM190_gpio.c SWM190_exti.c SWM190_timr.c SWM190_uart.c SWM190_adc.c SWM190_dma.c SWM190_i2c.c SWM190_pwm.c SWM190_spi.c SWM190_flash.c SWM190_rtc.c SWM190_wdt.c SWM190_cordic.c SWM190_div.c SWM190_cache.c SWM190_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
